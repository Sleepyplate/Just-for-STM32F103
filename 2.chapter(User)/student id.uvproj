# Keil uVision project student id.uvproj, settings and files
target student id (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: student id +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Sys
  group User
    ./: main.c
  group Sys
    ../Sys/: Timer.c
  group Driver
    ../Driver/: bsp_init.c bsp_led.c bsp_key.c bsp_seg.c bsp_onewire.c bsp_ds1302.c bsp_iic.c
