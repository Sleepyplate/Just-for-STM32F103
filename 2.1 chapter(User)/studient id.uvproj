# Keil uVision project studient id.uvproj, settings and files
target studient id (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: studient id +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Sys
  group user
    ./: main.c
  group sys
    ../Sys/: Timer.c Usart.c
  group driver
    ../Driver/: bsp_ds1302.c bsp_iic.c bsp_init.c bsp_key.c bsp_led.c bsp_onewire.c bsp_seg.c bsp_555_PWM_Freq.c bsp_ultrasonic.c
